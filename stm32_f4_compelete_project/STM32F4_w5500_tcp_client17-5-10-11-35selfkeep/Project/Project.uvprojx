# Keil uVision project Project.uvprojx, settings and files
target Embed-Net (ARM-ADS)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 uC99=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User\Ethernet\W5500;..\User\Ethernet;..\User\modbus_Driver\include;..\User\modbus_Driver\rtu;..\User\modbus_user\port;..\User\modbus_Driver\ascii;..\User\modbus_Driver\tcp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c delay.c delay.h flash_spi.c flash_spi.h main.c main.h modbusH.h sample.c sample.h stm32f4xx_conf.h stm32f4xx_it.h w25q128.c w25q128.h Inforchange.c Inforchange.h
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_tim.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Ethernet
    ../User/Ethernet/: socket.c spi.c wizchip_conf.c
    ../User/Ethernet/W5500/: w5500.c
  group Internet
    ../User/Internet/DNS/: dns.c
    ../User/Internet/DHCP/: dhcp.c
  group modbus
    ../User/modbus_Driver/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../User/modbus_Driver/rtu/: mbcrc.c mbrtu.c
    ../User/modbus_user/port/: portevent.c portserial.c porttimer.c
    ../User/modbus_user/: demo.c
    ../User/modbus_Driver/: mb.c
    ../User/modbus_Driver/ascii/: mbascii.c
    ../User/modbus_Driver/tcp/: mbtcp.c
